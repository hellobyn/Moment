# Keil uVision project Micromouse.uvproj, settings and files
target Micromouse (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Micromouse +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\Lib_inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Lib/Lib_Startup/: startup_stm32f10x_hd.s
  group Lib
    ./Lib/: core_cm3.c system_stm32f10x.c
    ./Lib/Lib_src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group Driver
    ../src/: Motor_Ctrl.c IRSensor_Prcs.c Interface.c ADXRS453.c
  group Maze
    ../src/: Delay.c Maze.c
  group Usart
    ../src/: Regtarge.c Usart.c
